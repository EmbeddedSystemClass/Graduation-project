# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MALLOC +hex
  c flags: Optim=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\MALLOC;..\MALLOC;..\USMART;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\EMWIN\Demo;..\HARDWARE\SD;..\TEXT;..\FATFS\exfuns;..\FATFS\src;..\EMWIN\STemWinHZ
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TOUCH/: ctiic.c gt9147.c ott2001a.c touch.c ft5206.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SD/: MMC_SD.C
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group MALLOC
    ../MALLOC/: malloc.c
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group EMWIN_Config
    ../EMWIN/STemWin/OS/: GUI_X.c
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM3_Keil.lib
  group TXET
    ../TEXT/: fontupd.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group EMWIN_HZ
    ../EMWIN/STemWinHZ/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_UC_EncodeNone.c GUICharPEx.c
  group EMWIN_GUI
    ../EMWIN/GUI_Builder/: ar_BkwindowDLG.c ar_MotorcontrolALLDLG.c ar_MotorcontrolWindowPC.c ar_NumPad.c ar_productioncontrolDLG.c ar_ProductionWindDLG.c ar_putinNumberDLG.c
